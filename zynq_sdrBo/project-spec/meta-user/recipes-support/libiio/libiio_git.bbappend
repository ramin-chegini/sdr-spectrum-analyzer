SRCREV = "fb64aca8adcaa607b482091b23b8edf10e5c1ad8"
SRC_URI = "git://github.com/analogdevicesinc/libiio;protocol=https;branch=2019_R2"
